# Keil uVision project hello.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: hello +hex
  AfterMake: fromelf -cvf .\Objects\hello.axf --vhx --32x1 -o hello.hex
  AfterMake: fromelf -cvf .\Objects\hello.axf -o hello.txt
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\meteo\Include;..\hello\Include;..\hardware\IIC;..\hardware\MSI001;..\hardware\QN8027;..\sys\delay;..\hardware\SYS;..\hardware\SYS;..\sys\system_gpio;..\sys\system_gpio;..\sys\cmsdk_drive;..\sys\system_usart;..\sys\system_usart;..\hardware\Nixie_tube;..\hardware\KEYBOARD;..\hardware\OLED;..\hardware\AT24Cxx;..\hardware\LCD
  asm include: ..\cmsis\Device\meteo\Include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup code
    ../cmsis/Device/meteo/Include/: startup_meteo.s
  group Application
    ../hello/Source/: LED.c main.c
  group System
    ../cmsis/Device/meteo/Source/: system_meteo.c
    ../sys/system_gpio/: system_gpio.c
    ../sys/system_usart/: system_usart.c
  group hardware
    ../hardware/MSI001/: msi001.c
    ../hardware/IIC/: myiic.c
    ../hardware/QN8027/: qn8027.c
    ../hardware/Nixie_tube/: Nixie_tube.c
    ../hardware/KEYBOARD/: keyboard.c
    ../hardware/OLED/: oled.c
    ../hardware/AT24Cxx/: 24cxx.c
    ../hardware/LCD/: lcd.c
  group sys
    ../sys/delay/: delay.c
software components: CMSIS:CORE 5.5.0
